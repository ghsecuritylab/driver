# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H743xx; RT_USING_DLIBC; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; board\ports; rt-thread\libcpu\arm\cortex-m7; libraries\STM32H7xx_HAL\CMSIS\Include; rt-thread\libcpu\arm\common; rt-thread\components\finsh; libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; .; rt-thread\components\libc\compilers\common; rt-thread\components\libc\compilers\dlib; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\drivers\include; board; board\CubeMX_Config\Inc; libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; rt-thread\components\drivers\spi; applications\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; board\ports; rt-thread\libcpu\arm\cortex-m7; libraries\STM32H7xx_HAL\CMSIS\Include; rt-thread\libcpu\arm\common; rt-thread\components\finsh; libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; .; rt-thread\components\libc\compilers\common; rt-thread\components\libc\compilers\dlib; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\drivers\include; board; board\CubeMX_Config\Inc; libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; rt-thread\components\drivers\spi
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Applications/func
    applications/func/: rocker.c
  group Applications/user
    applications/user/: AD7739.c LCD.c LCD_example.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    board/: board.c drv_mpu.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
  group finsh
    rt-thread/components/finsh/: cmd.c msh.c shell.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_spi.c stm32h7xx_hal_sram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
